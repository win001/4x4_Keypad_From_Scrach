<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\4x4_Keypad_From_Scrach.ewp</path>
  </project>
  <batchBuild />
</workspace>
